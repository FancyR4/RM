# Keil uVision project AIRInfantry.uvprojx, settings and files
target CodeClub (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IROM(0x08000000,0x00200000) IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AIRInfantry
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: .\CMSIS;.\FWLIB\include;.\MAIN;.\RTOS_BASE\include;.\RTOS_BASE\portable\RVDS\ARM_CM4F;.\TASK\TaskInfo;.\SDK;.\STARTUP;.\LINKWARE\Hardware;.\LINKWARE\System;.\TASK\TaskInfo;.\TASK\Chassis;.\TASK\Gimbal;.\TASK\Luncher;.\TASK\SystemControl;.\SDK;.\IMU;.\DSP\Include;.\Judge;.\TASK\Judge;.\TASK\calibrate_task;.\TASK\INS_task;.\TASK\FreeRTOS_middleware;.\TASK\Remote
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ./STARTUP/: startup_stm32f427xx.s
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c stm32f4xx_it.c
  group FWLIB
    ./FWLIB/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group LINKWARE
    ./LINKWARE/System/: sys.c delay.c
    ./LINKWARE/Hardware/: can.c laser.c usartBus.c gpio.c spi.c buzzer.c power.c usart.c exit_init.c adc.c flash.c timer.c
  group MAIN
    ./MAIN/: main.c
  group ROTS_BASE
    ./RTOS_BASE/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./RTOS_BASE/portable/RVDS/ARM_CM4F/: port.c
    ./RTOS_BASE/portable/MemMang/: heap_4.c
  group TASK
    ./TASK/TaskInfo/: Start_Task.c
    ./TASK/Chassis/: ChassisTask.c
    ./TASK/Gimbal/: GimbalTask.c
    ./TASK/SystemControl/: SysCtrl.c
    ./TASK/Judge/: judge_task.c
    ./TASK/calibrate_task/: calibrate_task.c
    ./TASK/INS_task/: INS_task.c
    ./TASK/FreeRTOS_middleware/: FreeRTOS_middleware.c
    ./TASK/Remote/: RemoteTask.c
  group IMU
    ./IMU/: AHRS_middleware.c ist8310driver.c ist8310driver_middleware.c mpu6500driver.c mpu6500driver_middleware.c AHRS.lib AHRS.h AHRS_middleware.h
  group UserLib
    ./SDK/: user_lib.c pid.c imupid.c kalman.c kalman_filter.c mem_malloc.c
  group DSP
    ./DSP/: arm_cortexM4lf_math.lib
    ./DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_sc000.h core_sc300.h
  group JUDGE
    ./Judge/: Judge_CRC.c Judge_Data.c usart_judge.c
